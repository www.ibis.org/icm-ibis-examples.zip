[IBIS Ver]  4.2
[File Name] ecircuit-nodal.ibs
[File Rev]  1.0
[Date]   01/21/2008
[Source]   This information is for demonstration purposes only.
[Notes]   The following information corresponds to no actual device.
[Disclaimer]   No license, express or implied, by estoppel or
  otherwise, to any intellectual property rights is granted
  by this document.
[Copyright]   Copyright (C) 2008, GEIA and the IBIS Open Forum
[Component]   External_Circuit_Nodal
[Manufacturer]  IBIS Open Forum
[Package]   | this section is overridden by [Package Model]
|   typ   min   max
R_pkg   0.00mOhm   0.00mOhm   0.00mOhm
L_pkg   0.0nH   0.00nH   0.00nH
C_pkg   0.0pF   0.00pF   0.00pF
[Pin]   signal_name model_name R_pin  L_pin  C_pin
| R_, L_ and C_pin are also overridden by [Package Model]
A1   IOPIN2   CIRCUITCALL   2m   4n   1p
A4   VCC   CIRCUITCALL   2m   4n   1p
A5   VSS   CIRCUITCALL   2m   4n   1p
| To make this work under ICM, without [Pin Mapping], you would connect
| a node map or a pin map using the names A1, A4 and A5 at the pin end,
| with A1, A1.A_puref and A1.A_pdref at the die end, if the supply for
| the buffer comes from the two supply pins named.  These connect to the
| nodes named in the [External Model] associated with pin A1.
| The power supplies can also be connected using [Pin Mapping]
| by pin name, using a simliar procedure.  Note that this may make the use
| of a tree path ICM structure impossible.
[Package Model]   ecircuit-nodal.icm
| ICM usage with IBIS package models requires the use of a [Package Model]
| with an .icm extension
[Node Declarations]
|Die Nodes
| no declarations are needed for A1, as it's an implicit pad
|Die Pads
pwrpad gndrefpad
[End Node Declarations]
[Circuit Call]  BUS_SPI
Signal_pin A1
| mapping  port   pad/node
Port_map   signal   A1   | implicit pad!
Port_map   cntrl   A1   | in this case, control connects to the signal pad
Port_map   pwr   A4   | implicit pad connection
Port_map   gndref   A5   | implicit pad connection
[End Circuit Call]
[External Circuit] BUS_SPI
Language SPICE
| Corner corner_name file_name   circuit_name (.subckt name)
Corner   Typ   buffer_typ.spi  buffer_io_typ
Ports signal my_drive my_enable my_receive cntrl
Ports pwr gndref
| D_to_A d_port   port1   port2   vlow vhigh trise tfall corner_name
D_to_A   D_drive  my_drive  gndref 0.0  3.3   0.5n  0.3n  Typ
D_to_A   D_enable my_enable gndref 0.0  3.3   0.5n  0.3n  Typ
| A_to_D d_port   port1   port2   vlow vhigh corner_name
A_to_D   D_receive my_receive gndref 0.8  2.0   Typ
[End External Circuit]
| Models and submodels in the file (0): 
