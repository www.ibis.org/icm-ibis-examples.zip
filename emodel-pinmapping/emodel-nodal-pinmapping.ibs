[IBIS Ver]  4.0
[File Name] emodel-nodal-pinmapping.ibs
[File Rev]  1.0
[Date]   01/21/2008
[Source]   This information is for demonstration purposes only.
[Notes]   The following information corresponds to no actual device.
[Disclaimer]   No license, express or implied, by estoppel or
  otherwise, to any intellectual property rights is granted
  by this document.
[Copyright]   Copyright (C) 2008, GEIA and the IBIS Open Forum
[Component]   External_Model_Nodal_Pinmapping
[Manufacturer]  IBIS Open Forum
[Package]   | this section is overridden by [Package Model]
|   typ   min   max
R_pkg   0.00mOhm   0.00mOhm   0.00mOhm
L_pkg   0.0nH   0.00nH   0.00nH
C_pkg   0.0pF   0.00pF   0.00pF
[Pin]   signal_name model_name R_pin  L_pin  C_pin
| R_, L_ and C_pin are also overridden by [Package Model]
A1   IOPIN2   IOBUFF   2m   4n   1p
A4   VCC   POWER   2m   4n   1p
A5   VSS   GND   2m   4n   1p
| To make this work under ICM, without [Pin Mapping], you would connect
| a node map or a pin map using the names A1, A4 and A5 at the pin end,
| with A1, A1.A_puref and A1.A_pdref at the die end, if the supply for
| the buffer comes from the two supply pins named.  These connect to the
| nodes named in the [External Model] associated with pin A1.
| The power supplies can also be connected using [Pin Mapping]
| by pin name, using a simliar procedure.  Note that this may make the use
| of a tree path ICM structure impossible.
[Package Model]   emodel-nodal-pinmapping.icm
| ICM usage with IBIS package models requires the use of a [Package Model]
| with an .icm extension
[Pin Mapping] pulldown_ref pullup_ref gnd_clamp_ref   power_clamp_ref
A1   gnd_rail   power_rail  gnd_rail   power_rail
A4   NC   power_rail  NC   NC
A5   gnd_rail   NC   NC   NC
| Note that pin mapping usage here is no different than in the case of
| [Model]!
[Model]   IOBUFF
Model_type   I/O
Vinl = 0.99V
Vinh = 1.650V
Vref = 0.000V
Cref = 10.000pF
Rref = 25.000Ohm
Vmeas = 1.0
|   typ   min   max
[Voltage Range]   3.300V   3.135V   3.465V
[Power Clamp Reference]   5.000V   4.750V   5.250V
[Temperature Range]   60.0   110.0   -10.0
[External Model]
Language SPICE
| Corner corner_name file_name   circuit_name (.subckt name)
Corner   Typ   buffer_typ.spi  buffer_io_typ
Ports A_signal my_drive my_enable my_receive
Ports A_puref A_pdref
| D_to_A d_port   port1   port2   vlow vhigh trise tfall corner_name
D_to_A   D_drive  my_drive  A_pdref 0.0  3.3   0.5n  0.3n  Typ
D_to_A   D_enable my_enable A_pdref 0.0  3.3   0.5n  0.3n  Typ
| A_to_D d_port   port1   port2   vlow vhigh corner_name
A_to_D   D_receive my_receive A_pdref 0.8  2.0   Typ
[End External Model]
[Ramp]
R_load = 60.00Ohm
|   typ   min   max
dV/dt_r   1.649V/481.483ps   1.467V/1.077ns  1.812V/299.994ps
dV/dt_f   1.730V/957.432ps   1.487V/2.240ns  1.915V/549.942ps
| Models and submodels in the file (1): IOBUFF (I/O)
